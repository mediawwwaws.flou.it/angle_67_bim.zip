Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: d41d6bbe-6c90-43fa-8bac-8a7cd7874570, VersionGUID: 212417c7-ff1f-426d-b5cf-4f8dfe52b473, NumberOfSaves: 4], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Planimetria di default], ExchangeRequirement [Architecture]
File name: Angle_67-Angle_67.ifc
Time: 2025-10-21T15:14:46+01:00
Written by: ODA SDAI 24.12
Made in: Autodesk Revit 25.1.0.44 (ITA) - IFC 25.4.0.27

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Pset_SiteCommon - Reference: Informazioni sul progetto
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - Reference: Informazioni sul progetto; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Informazioni sul progetto; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Informazioni sul progetto; sets with these values: 2
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey: Livello:Livello (2)
Pset_BuildingStoreyCommon - Reference: Livello
Altro - Categoria: Livelli; Famiglia: Livello; Famiglia e tipo: Livello: Livello; ID tipo: 927; Tipo: Livello
Quote - Altezza di calcolo: 0 m
Dati identità - Piano edificio: yes; Strutturale: no
Altro(Tipo) - Categoria: Livelli; Nome famiglia: Livello
Vincoli(Tipo) - Base quota altimetrica: Punto base progetto
Grafica(Tipo) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello : Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Dati identità(Tipo) - Nome del tipo: Livello
Name | LongName = Nome | Elevation (m) = Quota altimetrica (m)
0 - Piano Terra | 0 - Piano Terra | 0
1 - Piano Primo | 1 - Piano Primo | 3.1

# IfcFurniture: Angle_67:Angle_67, Angle_67:Angle_67:180190
In: 0 - Piano Terra
Type - Material: <Unnamed>
Type - Altro - Categoria: Arredi; Nome famiglia: Angle_67
Type - Vincoli - Prospetto di default: 0 m
Type - Quote - Altezza: 0 m
Type - Dati identità - Designer: Rodolfo Dordoni; Nome del tipo: Angle_67
Type - INFORMAZIONI - DESIGNER: Rodolfo Dordoni
Pset_EnvironmentalImpactIndicators - Reference: Angle_67; sets with these values: 2
Altro - Famiglia: Angle_67; Famiglia e tipo: Angle_67: Angle_67; ID tipo: 141240; Tipo: Angle_67
Vincoli - Host: Muro di base : Generico - 30 cm; Livello: 0 - Piano Terra; Offset da host: 0 m; Quota altimetrica da livello: 0 m; Sposta con gli elementi più vicini: no
Fasi - Fase di creazione: Stato di Progetto
